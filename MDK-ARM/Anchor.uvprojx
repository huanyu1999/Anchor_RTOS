# Keil uVision project Anchor.uvprojx, settings and files
target Anchor (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F405VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Anchor +hex
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F405xx
  c include: ..\01_Core\App\dw1000_application;..\01_Core\App\Inc;..\01_Core\Board\Inc;..\01_Core\Com\compiler;..\01_Core\Com\kalmanfilter;..\01_Core\Com\min_heap;..\01_Core\Com\multi_timer;..\01_Core\Com\multi_button;..\01_Core\Com\easylogger\inc;..\01_Core\Com\easylogger\plugins\file;..\01_Core\Com\uthash;..\01_Core\Dev\Inc;..\01_Core\Drv\Inc;..\01_Core\DW1000\decadriver;..\01_Core\DW1000\platform;..\01_Core\W5500\Ethernet;..\01_Core\W5500\Ethernet\W5500;..\01_Core\W5500\Internet\DHCP;..\02_Vendor_Lib;..\02_Vendor_Lib\STM32F4xx_HAL_Driver\Inc;..\02_Vendor_Lib\STM32F4xx_HAL_Driver\Inc\Legacy;..\02_Vendor_Lib\CMSIS\Core\Include;..\02_Vendor_Lib\CMSIS\Device\ST\STM32F4xx\Include;..\02_Vendor_Lib\CMSIS\Include;..\03_Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\03_Middlewares\Third_Party\FreeRTOS\Source\include;..\03_Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS_V2;..\03_Middlewares\Third_Party\FatFS\Src;..\03_Middlewares\STM32_USB_Device_Library\Class\MSC\Inc;..\03_Middlewares\STM32_USB_Device_Library\Core\Inc
  asm include: ..\02_Vendor_Lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ../01_Core/App/Src/: main.c freertos.c stm32f4xx_it.c dwt_delay.c app_network.c app_gnss.c
    ../01_Core/App/dw1000_application/: dw_sort.c dw_main.c instance_anchor.c
    ../01_Core/App/Inc/: FreeRTOSConfig.h
  group Board
    ../01_Core/Board/Src/: board_dw1000.c board_emmc.c board_gnss.c board_gpio.c board_w5500.c board_rx8130ce.c
  group Dev
    ../01_Core/Dev/Src/: dev_button.c dev_can.c dev_dw1000.c dev_emmc.c dev_gnss.c dev_jq8400.c dev_led_buzzer_dip.c dev_linkFatFs.c dev_rx8130ce.c dev_uart.c dev_w5500.c
  group Drv
    ../01_Core/Drv/Src/: can.c gpio.c iwdg.c spi.c usart.c drv_i2c.c drv_emmc.c drv_timer.c
  group Com
    ../01_Core/Com/kalmanfilter/: kalman.c
    ../01_Core/Com/multi_button/: com_multiButton.c
    ../01_Core/Com/multi_timer/: com_multiTimer.c
    ../01_Core/Com/easylogger/src/: elog.c elog_utils.c elog_async.c
    ../01_Core/Com/easylogger/port/: elog_port.c
  group Middlewares/FreeRTOS
    ../03_Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../03_Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../03_Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../03_Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Middlewares/FatFs
    ../03_Middlewares/Third_Party/FatFS/Src/: diskio.c ff.c
    ../03_Middlewares/Third_Party/FatFS/Option/: ffsystem.c ffunicode.c
  group DW1000
    ../01_Core/DW1000/platform/: deca_mutex.c deca_port.c deca_range_tables.c deca_sleep.c deca_spi.c
    ../01_Core/DW1000/decadriver/: deca_device.c deca_params_init.c
  group W5500
    ../01_Core/W5500/Ethernet/: socket.c wizchip_conf.c
    ../01_Core/W5500/Ethernet/W5500/: w5500.c
    ../01_Core/W5500/Internet/DHCP/: dhcp.c
  group Vendor Lib/STM32F4xx_HAL_Driver
    ../02_Vendor_Lib/: system_stm32f4xx.c stm32f4xx_hal_timebase_tim.c stm32f4xx_hal_msp.c
    ../02_Vendor_Lib/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_mmc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usb.c
  group MDK-ARM
    ./: startup_stm32f405xx.s
software components: CMSIS:CORE 6.0.0
